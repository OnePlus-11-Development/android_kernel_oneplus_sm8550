## drivers/staging/qcacld-3.0/configs/qca6490_defconfig
```kconfig
CONFIG_CNSS_QCA6490 := y
include $(WLAN_PLATFORM_ROOT)/config/kalama.conf
include $(WLAN_ROOT)/configs/default_defconfig
```
